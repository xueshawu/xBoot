# Keil uVision project Bootloader.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\Bsp\Gpio;..\Bsp\SysTick;..\Bsp\Uart;..\Bsp\Watchdog;..\Core;..\Cos;..\Hardware;..\IoHwAb;..\Rte;..\Rte;..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: bl_App.c
  group Bsp
    ../Bsp/Gpio/: Bsp_Gpio.c
    ../Bsp/SysTick/: Bsp_Systick.c
    ../Bsp/Watchdog/: Bsp_Watchdog.c
  group Core
    ../Core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Cos
    ../Cos/: Cos.c CosTask.c
  group Rte
    ../Rte/: Rte.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
